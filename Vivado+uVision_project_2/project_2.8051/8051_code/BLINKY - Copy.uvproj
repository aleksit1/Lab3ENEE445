# Keil uVision project BLINKY - Copy.uvproj, settings and files
target Simulator (MCS-51)
  device: P89C51RD2xx NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: BLINKY
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: BLINKY.C REG51F.H
  group Documentation
    ./: ABSTRACT.TXT
target MCBx51: 8xC51Rx (MCS-51)
  device: 8051 IP Core Oregano Systems
  cpu: IRAM(0-0x7F) XRAM(0-0xFFFF) IROM(0-0xFFF) CLOCK(12000000)
  output: BLINKY +hex
  AfterMake: hex2readmemh.exe BLINKY
  c flags: Optimize=8 SizeSpeed=1
